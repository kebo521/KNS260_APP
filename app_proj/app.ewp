# IAR project app.ewp, settings and files
configuration S260 (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LCD_RESOLUTION_320x240
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\lib; ..\lib\sdk; ..\lib\gui; ..\lib\gfs; ..\lib\tls; ..\app; ..\Customer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_S260.bin
  postbuild: ..\build_action\S260_Post.bat
  ILINK.IlinkOutputFile: app_S260.out
  ILINK.IlinkIcfFile: ..\src\startup\sdram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group app
    ../app/: App_main.c app_net.c app_sdk.c dataconv.c drv_wifi.c EvenMsg.c FactoryMenu.c gbk2unicode.c ks_crypt.c TermParfile.c ui_display.c ui_menu.c
  group customer
    ../Customer/: PE_customer.c PE_SweepPay.c PE_TermParSet.c PE_TradeProcess.c
  group lib
    ../lib/: app.a
