# IAR project app_72.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\app; ..\..\Customer; ..\..\lib; ..\..\lib\sdk; ..\..\lib\gui; ..\..\lib\tls; ..\..\lib\gfs
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.bin
  postbuild: Build_ksp.bat
  ILINK.IlinkOutputFile: app_72.out
  ILINK.IlinkIcfFile: sdram.icf
  ILINK.IlinkProgramEntryLabel: __startup_appmain
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group app
    ../../app/: App_main.c app_net.c app_sdk.c dataconv.c drv_wifi.c EvenMsg.c FactoryMenu.c gbk2unicode.c ks_crypt.c TermParfile.c ui_display.c ui_menu.c
  group Customer
    ../: PE_customer.c PE_SweepPay.c PE_TermParSet.c PE_TradeProcess.c
