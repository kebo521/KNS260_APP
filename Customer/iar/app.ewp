# IAR project app.ewp, settings and files
configuration FLASH_K21 (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\api\; ..\..\lib\; ..\..\app\; ..\..\app\Interface\; ..\..\app\Kernel\; ..\..\app\Basics\; ..\..\Customer_WeifuTong\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.bin
  postbuild: app.cmd
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: app.icf
  ILINK.IlinkProgramEntryLabel: __startup_appmain
configuration Flash_lib (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\api\; ..\..\lib\; ..\..\app\; ..\..\app\Interface\; ..\..\app\Kernel\; ..\..\app\Basics\; ..\..\Customer_ShengCan\
  group api
    ../../api/: emv.h emv_ics.h emv_tag.h ks_crypt.h ks_err_code.h ks_gui.h ks_sdk.h ks_stdlib.h ks_sysunit.h ks_type.h sdk.h
  group app
    ../../app/: app_main.c
  group app/Basics
    ../../app/Basics/: AdminTUSN.c app_net.c drv_wifi.c gbk2unicode.c md5.c QR_Encode.c TermParfile.c
  group app/Interface
    ../../app/Interface/: app_sdk.c dataconv.c ui_display.c ui_menu.c
  group app/Kernel
    ../../app/Kernel/: gMem.h kernel.a
  group Customer_WeifuTong
    ../: PE_customer.c PE_SweepPay.c PE_TermParSet.c PE_TradeProcess.c
  group lib
    ../../lib/: runtime.a
